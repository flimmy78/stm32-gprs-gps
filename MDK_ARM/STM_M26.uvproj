# Keil uVision project STM_M26.uvproj, settings and files
target STM_M26 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPS_M26_V101 +hex
  c flags: Optim=1
  c include: ..\bsp\basic;..\bsp\circularQueue;..\bsp\flash;..\bsp\gpio;..\bsp\gsm_m26;..\bsp\include;..\bsp\iwdg;..\bsp\jt_t808;..\bsp\rtc;..\bsp\sms_rsv;..\bsp\system;..\bsp\timer;..\bsp\usart;..\bsp\gbk_utf;..\libstm32\cmsis;..\libstm32\inc;..\libstm32\src;..\ucosii\port;..\ucosii\src;..\bsp\adc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group task
    ../task/: start.c sys_ctrl.c gps_rsv.c
  group jt_t808
    ../task/: server_ctrl.c
    ../bsp/jt_t808/: jt_t808_basic.c jt_t808_dsp.c jt_t808_cfg.c jt_t808_send.c
  group gprs
    ../task/: gsm_opreat.c
    ../bsp/gsm_m26/: gsm_m26.c
    ../bsp/sms_rsv/: sms_rsv.c
    ../bsp/gbk_utf/: gbk_utf.c
  group bsp
    ../bsp/system/: system.c
    ../bsp/adc/: adc.c
    ../bsp/rtc/: rtc.c
    ../bsp/gpio/: gpio.c
    ../bsp/iwdg/: iwdg.c
    ../bsp/usart/: usart.c
    ../bsp/flash/: flash.c
    ../bsp/basic/: basic.c
    ../bsp/circularQueue/: circularQueue.c
  group ucosii
    ../ucosii/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../ucosii/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group libstm32
    ../libstm32/src/: misc.c stm32f10x_it.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c
    ../libstm32/cmsis/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group notes
    ../note/: 版本说明.txt
